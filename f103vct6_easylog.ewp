# IAR project f103vct6_easylog.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VC ST STM32F103VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: CMSIS\system; FWLIB\inc; User\inc; CMSIS; board_mcu\inc; User\inc; board_mcu; User\src; easylogger\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: f103vct6_freertos.bin
  ILINK.IlinkOutputFile: HN_LoRa_CCU.out
  ILINK.IlinkIcfFile: E:\桌面\FreeRTOS\f103vct6_freertos\CMSIS\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board_mcu
    board_mcu/src/: gpio.c led_watchdog.c rs485.c uart.c
  group CMSIS
    CMSIS/: stm32f10x_it.c
  group CMSIS/startup
    CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS/system
    CMSIS/system/: system_stm32f10x.c
  group doc
    doc/: Readme.txt
  group easylogger
    easylogger/src/: elog.c elog_port.c elog_utils.c
  group FWLIB
    FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    User/src/: main.c
